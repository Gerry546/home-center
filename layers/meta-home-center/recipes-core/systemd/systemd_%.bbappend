PACKAGECONFIG:append = " networkd resolved"

RDEPENDS:${PN}:append:hometerminal-cm4 = " wpa-supplicant "