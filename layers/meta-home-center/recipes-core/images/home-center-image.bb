SUMMARY = "The Image to run the home-center"
AUTHOR = "Tom Geelen"

LICENSE = "MIT"

require home-center-common.inc
